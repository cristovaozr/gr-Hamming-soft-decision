options:
  parameters:
    author: cristovaozr
    generate_options: qt_gui
    id: bergenerator_example
    output_language: python
    title: BER Generator Example
  states: {}

blocks:
- name: esno
  id: variable
  parameters:
    comment: ESSE FOI O SEGREDO DO SUCESSO!
    value: numpy.arange(00, 10.0, .5)
  states: {}
- name: num_curves
  id: variable
  parameters:
    comment: ESSE FOI O SEGREDO DO SUCESSO!
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: variable_dummy_decoder_def_0
  id: variable_dummy_decoder_def
  parameters:
    dim1: '1'
    framebits: '2048'
    ndim: '1'
  states: {}
- name: variable_dummy_encoder_def_0
  id: variable_dummy_encoder_def
  parameters:
    dim1: '1'
    framebits: '2048'
    ndim: '1'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fec_bercurve_generator_0
  id: fec_bercurve_generator
  parameters:
    decoder_list: '[variable_dummy_decoder_def_0]*len(esno)'
    encoder_list: '[variable_dummy_encoder_def_0]*len(esno)'
    esno: esno
    puncpat: '''11'''
    samp_rate: '3200000'
  states: {bus_source: true}
- name: qtgui_bercurve_sink_0
  id: qtgui_bercurve_sink
  parameters:
    berlimit: '-6.0'
    berminerrors: '100'
    curvenames: '["dummy curve"]'
    esno: esno
    label1: Dummy Encoder
    num_curves: num_curves
  states: {bus_sink: true}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [fec_bercurve_generator_0, '40', qtgui_bercurve_sink_0, '40']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
