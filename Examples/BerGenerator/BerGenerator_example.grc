options:
  parameters:
    author: cristovaozr
    generate_options: qt_gui
    id: bergenerator_example
    output_language: python
    title: BER Generator Example
  states: {}

blocks:
- name: esno
  id: variable
  parameters:
    comment: ESSE FOI O SEGREDO DO SUCESSO!
    value: numpy.arange(00, 8, 0.5)
  states: {}
- name: num_curves
  id: variable
  parameters:
    comment: ESSE FOI O SEGREDO DO SUCESSO!
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: variable_cc_decoder_def_0
  id: variable_cc_decoder_def
  parameters:
    dim1: '1'
    framebits: '128'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '1'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: variable_ccsds_encoder_def_0
  id: variable_ccsds_encoder_def
  parameters:
    dim1: '1'
    framebits: '128'
    mode: fec.CC_STREAMING
    ndim: '1'
    state_start: '0'
  states: {}
- name: variable_dummy_decoder_def_0
  id: variable_dummy_decoder_def
  parameters:
    dim1: '1'
    framebits: '2048'
    ndim: '1'
  states: {}
- name: variable_dummy_encoder_def_0
  id: variable_dummy_encoder_def
  parameters:
    dim1: '1'
    framebits: '2048'
    ndim: '1'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fec_bercurve_generator_0
  id: fec_bercurve_generator
  parameters:
    decoder_list: '[variable_dummy_decoder_def_0]*len(esno)'
    encoder_list: '[variable_dummy_encoder_def_0]*len(esno)'
    esno: esno
    puncpat: '''11'''
    samp_rate: '3200000'
  states: {bus_source: true}
- name: fec_bercurve_generator_0_0
  id: fec_bercurve_generator
  parameters:
    decoder_list: '[variable_cc_decoder_def_0]*len(esno)'
    encoder_list: '[variable_ccsds_encoder_def_0]*len(esno)'
    esno: esno
    puncpat: '''11'''
    samp_rate: '3200000'
  states: {bus_source: true}
- name: qtgui_bercurve_sink_0
  id: qtgui_bercurve_sink
  parameters:
    berlimit: '-7.0'
    berminerrors: '50'
    esno: esno
    label1: Dummy Encoder
    label2: CCSDS
    num_curves: num_curves
    width1: '2'
    width2: '2'
  states: {bus_sink: true}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [fec_bercurve_generator_0, '32', qtgui_bercurve_sink_0, '64']
- [fec_bercurve_generator_0_0, '32', qtgui_bercurve_sink_0, '65']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
