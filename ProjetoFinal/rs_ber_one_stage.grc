options:
  parameters:
    author: Cristóvão Ruino
    generate_options: hb
    id: rs_ber_one_stage
    output_language: python
    title: RS BER Generator Stage
  states: {}

blocks:
- name: bpsk_constelation
  id: variable_constellation
  parameters:
    npwr: '0'
    precision: '8'
    soft_dec_lut: '"auto"'
    type: bpsk
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_voltage
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '223'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '255'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '255'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '223'
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk_constelation
  states: {state: disabled}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: bpsk_constelation
  states: {state: disabled}
- name: dtv_dvbt_reed_solomon_dec_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '1'
    gfpoly: '0x11d'
    k: '223'
    m: '8'
    n: '255'
    p: '2'
    s: '0'
    t: '16'
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '1'
    gfpoly: '0x11d'
    k: '223'
    m: '8'
    n: '255'
    p: '2'
    s: '0'
    t: '16'
  states: {}
- name: noise_voltage
  id: parameter
  parameters:
    label: Noise Voltage
    type: eng_float
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: rs_output
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: rs_input
    type: byte
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [blocks_complex_to_interleaved_char_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_add_xx_0, '0']
- [blocks_stream_to_vector_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [blocks_stream_to_vector_0_0, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_vector_to_stream_1, '0', pad_sink_0, '0']
- [dtv_dvbt_reed_solomon_dec_0, '0', blocks_vector_to_stream_1, '0']
- [dtv_dvbt_reed_solomon_enc_0, '0', blocks_vector_to_stream_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
