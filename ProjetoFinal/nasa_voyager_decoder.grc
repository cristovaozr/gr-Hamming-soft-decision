options:
  parameters:
    author: Cristóvão Rufino
    generate_options: hb
    id: nasa_voyager_decoder
    output_language: python
    title: NASA Voyager Decoder
  states: {}

blocks:
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    comment: |-
      A saída do bloco precisa ser posta
      em float para que o Decode CCSDS 27
      faça o Viterbi
    scale: '.5'
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '255'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '223'
    type: byte
  states: {}
- name: dtv_dvbt_reed_solomon_dec_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '1'
    gfpoly: '0x11d'
    k: '223'
    m: '8'
    n: '255'
    p: '2'
    s: '0'
    t: '16'
  states: {}
- name: fec_decode_ccsds_27_fb_0
  id: fec_decode_ccsds_27_fb
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', fec_decode_ccsds_27_fb_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_char_to_float_0, '0']
- [dtv_dvbt_reed_solomon_dec_0, '0', blocks_vector_to_stream_1, '0']
- [fec_decode_ccsds_27_fb_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
