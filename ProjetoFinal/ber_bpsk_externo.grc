options:
  parameters:
    author: cristovaozr
    generate_options: qt_gui
    id: ber_bpsk_externo
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/bytes_originais.bin
    type: byte
    vlen: '8'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/snr0db.bin
    type: byte
    vlen: '8'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/snr1db.bin
    type: byte
    vlen: '8'
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/snr3db.bin
    type: byte
    vlen: '8'
  states: {}
- name: blocks_file_sink_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/snr5db.bin
    type: byte
    vlen: '8'
  states: {}
- name: blocks_file_sink_0_0_0_2
  id: blocks_file_sink
  parameters:
    file: /tmp/snr7db.bin
    type: byte
    vlen: '8'
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/snr2db.bin
    type: byte
    vlen: '8'
  states: {}
- name: blocks_file_sink_0_0_2
  id: blocks_file_sink
  parameters:
    file: /tmp/snr4db.bin
    type: byte
    vlen: '8'
  states: {}
- name: blocks_file_sink_0_0_3
  id: blocks_file_sink
  parameters:
    file: /tmp/snr6db.bin
    type: byte
    vlen: '8'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_1_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '8'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '8'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '8'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '8'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: '8'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_3
  id: blocks_stream_to_vector
  parameters:
    num_items: '8'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_4
  id: blocks_stream_to_vector
  parameters:
    num_items: '8'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_5
  id: blocks_stream_to_vector
  parameters:
    num_items: '8'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_6
  id: blocks_stream_to_vector
  parameters:
    num_items: '8'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: bpsk_ber_generator_0
  id: bpsk_ber_generator
  parameters: {}
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_file_sink_0_0_1, '0']
- [blocks_stream_to_vector_0_2, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_stream_to_vector_0_3, '0', blocks_file_sink_0_0_2, '0']
- [blocks_stream_to_vector_0_4, '0', blocks_file_sink_0_0_0_1, '0']
- [blocks_stream_to_vector_0_5, '0', blocks_file_sink_0_0_3, '0']
- [blocks_stream_to_vector_0_6, '0', blocks_file_sink_0_0_0_2, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_1, '0']
- [bpsk_ber_generator_0, '0', blocks_stream_to_vector_0, '0']
- [bpsk_ber_generator_0, '1', blocks_stream_to_vector_0_0, '0']
- [bpsk_ber_generator_0, '10', blocks_null_sink_0_0_0, '0']
- [bpsk_ber_generator_0, '11', blocks_stream_to_vector_0_4, '0']
- [bpsk_ber_generator_0, '12', blocks_null_sink_0_1_0, '0']
- [bpsk_ber_generator_0, '13', blocks_stream_to_vector_0_5, '0']
- [bpsk_ber_generator_0, '14', blocks_null_sink_0_1_0_0, '0']
- [bpsk_ber_generator_0, '15', blocks_stream_to_vector_0_6, '0']
- [bpsk_ber_generator_0, '2', blocks_null_sink_0, '0']
- [bpsk_ber_generator_0, '3', blocks_stream_to_vector_0_0_0, '0']
- [bpsk_ber_generator_0, '4', blocks_null_sink_0_0, '0']
- [bpsk_ber_generator_0, '5', blocks_stream_to_vector_0_1, '0']
- [bpsk_ber_generator_0, '6', blocks_null_sink_0_1, '0']
- [bpsk_ber_generator_0, '7', blocks_stream_to_vector_0_2, '0']
- [bpsk_ber_generator_0, '8', blocks_null_sink_0_2, '0']
- [bpsk_ber_generator_0, '9', blocks_stream_to_vector_0_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
