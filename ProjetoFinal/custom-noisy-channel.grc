options:
  parameters:
    author: Cristóvão Rufino
    generate_options: hb
    id: custom_channel
    output_language: python
    title: Custom Noisy Channel
  states: {}

blocks:
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: noise_voltage
    type: complex
  states: {}
- name: noise_voltage
  id: parameter
  parameters:
    label: Noise Voltage
    type: eng_float
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: noise
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [pad_source_0, '0', blocks_add_xx_0, '0']
- [pad_source_1, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
