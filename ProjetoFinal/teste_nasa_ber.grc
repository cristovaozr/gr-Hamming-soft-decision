options:
  parameters:
    author: Cristóvão Rufino
    generate_options: qt_gui
    id: teste_nasa_ber
    output_language: python
    title: NASA BER Test
  states: {}

blocks:
- name: esno
  id: variable
  parameters:
    comment: ESSE FOI O SEGREDO DO SUCESSO!
    value: numpy.arange(0, 8, 1)
  states: {}
- name: num_curves
  id: variable
  parameters:
    comment: ESSE FOI O SEGREDO DO SUCESSO!
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: nasa_ber_generator_0
  id: nasa_ber_generator
  parameters: {}
  states: {}
- name: qtgui_bercurve_sink_0
  id: qtgui_bercurve_sink
  parameters:
    berlimit: '-6.5'
    berminerrors: '25'
    esno: esno
    num_curves: num_curves
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [nasa_ber_generator_0, '0', qtgui_bercurve_sink_0, '0']
- [nasa_ber_generator_0, '1', qtgui_bercurve_sink_0, '1']
- [nasa_ber_generator_0, '10', qtgui_bercurve_sink_0, '10']
- [nasa_ber_generator_0, '11', qtgui_bercurve_sink_0, '11']
- [nasa_ber_generator_0, '12', qtgui_bercurve_sink_0, '12']
- [nasa_ber_generator_0, '13', qtgui_bercurve_sink_0, '13']
- [nasa_ber_generator_0, '14', qtgui_bercurve_sink_0, '14']
- [nasa_ber_generator_0, '15', qtgui_bercurve_sink_0, '15']
- [nasa_ber_generator_0, '2', qtgui_bercurve_sink_0, '2']
- [nasa_ber_generator_0, '3', qtgui_bercurve_sink_0, '3']
- [nasa_ber_generator_0, '4', qtgui_bercurve_sink_0, '4']
- [nasa_ber_generator_0, '5', qtgui_bercurve_sink_0, '5']
- [nasa_ber_generator_0, '6', qtgui_bercurve_sink_0, '6']
- [nasa_ber_generator_0, '7', qtgui_bercurve_sink_0, '7']
- [nasa_ber_generator_0, '8', qtgui_bercurve_sink_0, '8']
- [nasa_ber_generator_0, '9', qtgui_bercurve_sink_0, '9']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
