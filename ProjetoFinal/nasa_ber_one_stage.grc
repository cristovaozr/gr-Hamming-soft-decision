options:
  parameters:
    author: Cristóvão Rufino
    generate_options: hb
    id: nasa_ber_one_stage
    output_language: python
    title: NASA BER One Stage
  states: {}

blocks:
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: custom_channel_0_0
  id: custom_channel
  parameters:
    noise_voltage: noise_voltage
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BPSK Modulator',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):

              for i, item in enumerate(input_items[0]):
                  if item == 0:
                      output_items[0][i] = -1.0
                  else:
                      output_items[0][i] = 1.0

              return len(output_items[0])
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BPSK Demodulator',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.byte]
              )

          def work(self, input_items, output_items):
              for i, item in enumerate(input_items[0]):
                  if item.real < 0:
                      output_items[0][i] = 0
                  else:
                      output_items[0][i] = 1

              return len(output_items[0])
  states: {}
- name: nasa_voyager_decoder_0
  id: nasa_voyager_decoder
  parameters: {}
  states: {}
- name: nasa_voyager_encoder_0
  id: nasa_voyager_encoder
  parameters: {}
  states: {}
- name: noise_voltage
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [analog_noise_source_x_0, '0', custom_channel_0_0, '1']
- [custom_channel_0_0, '0', epy_block_1, '0']
- [epy_block_0, '0', custom_channel_0_0, '0']
- [epy_block_1, '0', nasa_voyager_decoder_0, '0']
- [nasa_voyager_decoder_0, '0', pad_sink_0, '0']
- [nasa_voyager_encoder_0, '0', epy_block_0, '0']
- [pad_source_0, '0', nasa_voyager_encoder_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
