options:
  parameters:
    author: Cristóvão Rufino
    generate_options: hb
    id: cc_ber_one_stage
    output_language: python
    title: CC BER One Stage
  states: {}

blocks:
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '.5'
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: custom_channel_0
  id: custom_channel
  parameters:
    noise_voltage: noise_voltage
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BPSK Modulator',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):

              for i, item in enumerate(input_items[0]):
                  if item == 0:
                      output_items[0][i] = -1.0
                  else:
                      output_items[0][i] = 1.0

              return len(output_items[0])
  states: {}
- name: fec_decode_ccsds_27_fb_0
  id: fec_decode_ccsds_27_fb
  parameters: {}
  states: {}
- name: fec_encode_ccsds_27_bb_0
  id: fec_encode_ccsds_27_bb
  parameters: {}
  states: {}
- name: noise_voltage
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [analog_noise_source_x_0, '0', custom_channel_0, '1']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', fec_decode_ccsds_27_fb_0, '0']
- [custom_channel_0, '0', blocks_complex_to_real_0, '0']
- [epy_block_0, '0', custom_channel_0, '0']
- [fec_decode_ccsds_27_fb_0, '0', pad_sink_0, '0']
- [fec_encode_ccsds_27_bb_0, '0', epy_block_0, '0']
- [pad_source_0, '0', fec_encode_ccsds_27_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
