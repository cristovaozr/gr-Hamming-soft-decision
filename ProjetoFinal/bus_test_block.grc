options:
  parameters:
    author: cristovaozr
    generate_options: hb
    id: bus_test_block
    output_language: python
    title: BUS Test Block
  states: {}

blocks:
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_LAPLACIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_2
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_IMPULSE
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_3
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_2
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out0
    type: complex
  states: {}
- name: pad_sink_0_1
  id: pad_sink
  parameters:
    label: out1
    type: complex
  states: {}
- name: pad_sink_0_2
  id: pad_sink
  parameters:
    label: out2
    type: complex
  states: {}
- name: pad_sink_0_3
  id: pad_sink
  parameters:
    label: out3
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_1, '0', blocks_add_xx_0_0, '0']
- [analog_noise_source_x_2, '0', blocks_add_xx_0_1, '0']
- [analog_noise_source_x_3, '0', blocks_add_xx_0_2, '0']
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_add_xx_0_0, '0', pad_sink_1, '0']
- [blocks_add_xx_0_1, '0', pad_sink_2, '0']
- [blocks_add_xx_0_2, '0', pad_sink_3, '0']
- [pad_source_0, '0', blocks_add_xx_0, '1']
- [pad_source_0, '0', blocks_add_xx_0_0, '1']
- [pad_source_0, '0', blocks_add_xx_0_1, '1']
- [pad_source_0, '0', blocks_add_xx_0_2, '1']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
