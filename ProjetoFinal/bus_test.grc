options:
  parameters:
    author: cristovaozr
    generate_options: qt_gui
    id: bus_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: bus_test_block_0
  id: bus_test_block
  parameters: {}
  states: {bus_source: true}
- name: qtgui_bercurve_sink_0
  id: qtgui_bercurve_sink
  parameters:
    berlimit: '-7.0'
    berminerrors: '100'
  states: {bus_sink: true}

connections:
- [bus_test_block_0, '4', qtgui_bercurve_sink_0, '16']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
