options:
  parameters:
    author: Cristóvão Rufino
    generate_options: qt_gui
    id: ber_output_file
    output_language: python
    title: BER Data output to file
  states: {}

blocks:
- name: noise_voltage
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '2'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/cristovaozr/workspace/Doutorado/cce/gr-Hamming-soft-decision/ProjetoFinal/output-orig-file.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/cristovaozr/workspace/Doutorado/cce/gr-Hamming-soft-decision/ProjetoFinal/output-noisy-file.bin
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: custom_channel_0
  id: custom_channel
  parameters:
    noise_voltage: noise_voltage
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BPSK Modulator',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):

              for i, item in enumerate(input_items[0]):
                  if item == 0:
                      output_items[0][i] = -1.0
                  else:
                      output_items[0][i] = 1.0

              return len(output_items[0])
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BPSK Demodulator',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.byte]
              )

          def work(self, input_items, output_items):
              for i, item in enumerate(input_items[0]):
                  if item.real < 0:
                      output_items[0][i] = 0
                  else:
                      output_items[0][i] = 1

              return len(output_items[0])
  states: {}

connections:
- [analog_noise_source_x_0, '0', custom_channel_0, '1']
- [analog_random_uniform_source_x_0, '0', blocks_file_sink_0, '0']
- [analog_random_uniform_source_x_0, '0', epy_block_0, '0']
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [custom_channel_0, '0', epy_block_1, '0']
- [epy_block_0, '0', custom_channel_0, '0']
- [epy_block_1, '0', blocks_file_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
