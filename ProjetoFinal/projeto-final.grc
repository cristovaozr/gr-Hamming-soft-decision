options:
  parameters:
    author: Cristóvão, José Ribamar e Robson
    generate_options: qt_gui
    id: projeto_final
    output_language: python
    title: Deep Space Modulation Simulator
  states: {}

blocks:
- name: esno
  id: variable
  parameters:
    comment: ESSE FOI O SEGREDO DO SUCESSO!
    value: numpy.arange(0, 4, 0.5)
  states: {}
- name: num_curves
  id: variable
  parameters:
    comment: ESSE FOI O SEGREDO DO SUCESSO!
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '2'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: qtgui_bercurve_sink_0
  id: qtgui_bercurve_sink
  parameters:
    berlimit: '-7.0'
    berminerrors: '50'
    esno: esno
  states: {}
- name: rs_ber_generator2_0
  id: rs_ber_generator2
  parameters: {}
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: randSource
  states: {}

connections:
- [analog_random_uniform_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [rs_ber_generator2_0, '0', qtgui_bercurve_sink_0, '0']
- [rs_ber_generator2_0, '1', qtgui_bercurve_sink_0, '1']
- [rs_ber_generator2_0, '10', qtgui_bercurve_sink_0, '10']
- [rs_ber_generator2_0, '11', qtgui_bercurve_sink_0, '11']
- [rs_ber_generator2_0, '12', qtgui_bercurve_sink_0, '12']
- [rs_ber_generator2_0, '13', qtgui_bercurve_sink_0, '13']
- [rs_ber_generator2_0, '14', qtgui_bercurve_sink_0, '14']
- [rs_ber_generator2_0, '15', qtgui_bercurve_sink_0, '15']
- [rs_ber_generator2_0, '2', qtgui_bercurve_sink_0, '2']
- [rs_ber_generator2_0, '3', qtgui_bercurve_sink_0, '3']
- [rs_ber_generator2_0, '4', qtgui_bercurve_sink_0, '4']
- [rs_ber_generator2_0, '5', qtgui_bercurve_sink_0, '5']
- [rs_ber_generator2_0, '6', qtgui_bercurve_sink_0, '6']
- [rs_ber_generator2_0, '7', qtgui_bercurve_sink_0, '7']
- [rs_ber_generator2_0, '8', qtgui_bercurve_sink_0, '8']
- [rs_ber_generator2_0, '9', qtgui_bercurve_sink_0, '9']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
