options:
  parameters:
    author: Cristóvão, José Ribamar e Robson
    generate_options: qt_gui
    id: projeto_final
    output_language: python
    title: Deep Space Modulation Simulator
  states: {}

blocks:
- name: esno
  id: variable
  parameters:
    comment: ESSE FOI O SEGREDO DO SUCESSO!
    value: numpy.arange(0, 8, 1)
  states: {}
- name: num_curves
  id: variable
  parameters:
    comment: ESSE FOI O SEGREDO DO SUCESSO!
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: bpsk_ber_generator_0
  id: bpsk_ber_generator
  parameters: {}
  states: {}
- name: cc_ber_generator_0
  id: cc_ber_generator
  parameters: {}
  states: {}
- name: nasa_ber_generator_0
  id: nasa_ber_generator
  parameters: {}
  states: {}
- name: qtgui_bercurve_sink_0
  id: qtgui_bercurve_sink
  parameters:
    berlimit: '-7.0'
    berminerrors: '25'
    curvenames: '[''RS(255,223)'', ''BPSK AWGN'']'
    esno: esno
    label1: RS(255,223)
    label2: BPSK AWGN
    label3: CC R=0.5 K=7
    label4: Código Conc.
    num_curves: num_curves
  states: {}
- name: rs_ber_generator2_0
  id: rs_ber_generator2
  parameters: {}
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [bpsk_ber_generator_0, '0', qtgui_bercurve_sink_0, '16']
- [bpsk_ber_generator_0, '1', qtgui_bercurve_sink_0, '17']
- [bpsk_ber_generator_0, '10', qtgui_bercurve_sink_0, '26']
- [bpsk_ber_generator_0, '11', qtgui_bercurve_sink_0, '27']
- [bpsk_ber_generator_0, '12', qtgui_bercurve_sink_0, '28']
- [bpsk_ber_generator_0, '13', qtgui_bercurve_sink_0, '29']
- [bpsk_ber_generator_0, '14', qtgui_bercurve_sink_0, '30']
- [bpsk_ber_generator_0, '15', qtgui_bercurve_sink_0, '31']
- [bpsk_ber_generator_0, '2', qtgui_bercurve_sink_0, '18']
- [bpsk_ber_generator_0, '3', qtgui_bercurve_sink_0, '19']
- [bpsk_ber_generator_0, '4', qtgui_bercurve_sink_0, '20']
- [bpsk_ber_generator_0, '5', qtgui_bercurve_sink_0, '21']
- [bpsk_ber_generator_0, '6', qtgui_bercurve_sink_0, '22']
- [bpsk_ber_generator_0, '7', qtgui_bercurve_sink_0, '23']
- [bpsk_ber_generator_0, '8', qtgui_bercurve_sink_0, '24']
- [bpsk_ber_generator_0, '9', qtgui_bercurve_sink_0, '25']
- [cc_ber_generator_0, '0', qtgui_bercurve_sink_0, '32']
- [cc_ber_generator_0, '1', qtgui_bercurve_sink_0, '33']
- [cc_ber_generator_0, '10', qtgui_bercurve_sink_0, '42']
- [cc_ber_generator_0, '11', qtgui_bercurve_sink_0, '43']
- [cc_ber_generator_0, '12', qtgui_bercurve_sink_0, '44']
- [cc_ber_generator_0, '13', qtgui_bercurve_sink_0, '45']
- [cc_ber_generator_0, '14', qtgui_bercurve_sink_0, '46']
- [cc_ber_generator_0, '15', qtgui_bercurve_sink_0, '47']
- [cc_ber_generator_0, '2', qtgui_bercurve_sink_0, '34']
- [cc_ber_generator_0, '3', qtgui_bercurve_sink_0, '35']
- [cc_ber_generator_0, '4', qtgui_bercurve_sink_0, '36']
- [cc_ber_generator_0, '5', qtgui_bercurve_sink_0, '37']
- [cc_ber_generator_0, '6', qtgui_bercurve_sink_0, '38']
- [cc_ber_generator_0, '7', qtgui_bercurve_sink_0, '39']
- [cc_ber_generator_0, '8', qtgui_bercurve_sink_0, '40']
- [cc_ber_generator_0, '9', qtgui_bercurve_sink_0, '41']
- [nasa_ber_generator_0, '0', qtgui_bercurve_sink_0, '48']
- [nasa_ber_generator_0, '1', qtgui_bercurve_sink_0, '49']
- [nasa_ber_generator_0, '10', qtgui_bercurve_sink_0, '58']
- [nasa_ber_generator_0, '11', qtgui_bercurve_sink_0, '59']
- [nasa_ber_generator_0, '12', qtgui_bercurve_sink_0, '60']
- [nasa_ber_generator_0, '13', qtgui_bercurve_sink_0, '61']
- [nasa_ber_generator_0, '14', qtgui_bercurve_sink_0, '62']
- [nasa_ber_generator_0, '15', qtgui_bercurve_sink_0, '63']
- [nasa_ber_generator_0, '2', qtgui_bercurve_sink_0, '50']
- [nasa_ber_generator_0, '3', qtgui_bercurve_sink_0, '51']
- [nasa_ber_generator_0, '4', qtgui_bercurve_sink_0, '52']
- [nasa_ber_generator_0, '5', qtgui_bercurve_sink_0, '53']
- [nasa_ber_generator_0, '6', qtgui_bercurve_sink_0, '54']
- [nasa_ber_generator_0, '7', qtgui_bercurve_sink_0, '55']
- [nasa_ber_generator_0, '8', qtgui_bercurve_sink_0, '56']
- [nasa_ber_generator_0, '9', qtgui_bercurve_sink_0, '57']
- [rs_ber_generator2_0, '0', qtgui_bercurve_sink_0, '0']
- [rs_ber_generator2_0, '1', qtgui_bercurve_sink_0, '1']
- [rs_ber_generator2_0, '10', qtgui_bercurve_sink_0, '10']
- [rs_ber_generator2_0, '11', qtgui_bercurve_sink_0, '11']
- [rs_ber_generator2_0, '12', qtgui_bercurve_sink_0, '12']
- [rs_ber_generator2_0, '13', qtgui_bercurve_sink_0, '13']
- [rs_ber_generator2_0, '14', qtgui_bercurve_sink_0, '14']
- [rs_ber_generator2_0, '15', qtgui_bercurve_sink_0, '15']
- [rs_ber_generator2_0, '2', qtgui_bercurve_sink_0, '2']
- [rs_ber_generator2_0, '3', qtgui_bercurve_sink_0, '3']
- [rs_ber_generator2_0, '4', qtgui_bercurve_sink_0, '4']
- [rs_ber_generator2_0, '5', qtgui_bercurve_sink_0, '5']
- [rs_ber_generator2_0, '6', qtgui_bercurve_sink_0, '6']
- [rs_ber_generator2_0, '7', qtgui_bercurve_sink_0, '7']
- [rs_ber_generator2_0, '8', qtgui_bercurve_sink_0, '8']
- [rs_ber_generator2_0, '9', qtgui_bercurve_sink_0, '9']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
