options:
  parameters:
    author: Cristóvão Rufino
    generate_options: hb
    id: nasa_voyager_encoder
    output_language: python
    title: NASA Voyager Encoder
  states: {}

blocks:
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '223'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '255'
    type: byte
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '1'
    gfpoly: '0x11d'
    k: '223'
    m: '8'
    n: '255'
    p: '2'
    s: '0'
    t: '16'
  states: {}
- name: fec_encode_ccsds_27_bb_0
  id: fec_encode_ccsds_27_bb
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [blocks_vector_to_stream_0, '0', pad_sink_0, '0']
- [dtv_dvbt_reed_solomon_enc_0, '0', blocks_vector_to_stream_0, '0']
- [fec_encode_ccsds_27_bb_0, '0', blocks_stream_to_vector_0, '0']
- [pad_source_0, '0', fec_encode_ccsds_27_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
